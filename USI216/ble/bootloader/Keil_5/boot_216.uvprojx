# Keil uVision project boot_216.uvprojx, settings and files
target GR5515_SK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: oppo_second_boot_216 +hex
  AfterMake: fromelf.exe --bin --output ..\..\..\image\bootloader\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK,USE_SECOND_BOOT_MODE
  c include: ..\Src\platform;..\Src\user;..\Src\config;..\..\..\..\GR551x_SDK_V1.7.0\components\app_drivers\inc;..\..\..\..\GR551x_SDK_V1.7.0\components\boards;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\gr551x;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\st7735;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\vs1005;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_alarm;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_assert;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_error;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_key;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_log;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_queue;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_timer;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\at_cmd;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\bsp;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\dfu_master;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\dfu_port;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\gui;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\gui\gui_config;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\hal_flash;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\hci_uart;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\pmu_calibration;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\ring_buffer;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\sensorsim;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\utility;..\..\..\..\GR551x_SDK_V1.7.0\components\patch\ind;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ams_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ancs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ans;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ans_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bas;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bas_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\common;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cscs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cts;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cts_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\dis;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\dis_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gls;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gus;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gus_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hids;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrrcps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hts;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ias;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\lls;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ndcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\otas;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\otas_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pass;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pass_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rscs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rscs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rtus;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\sample;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ths;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ths_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\thscps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\tps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\wechat;..\..\..\..\GR551x_SDK_V1.7.0\components\sdk\;..\..\..\..\GR551x_SDK_V1.7.0\drivers\inc;..\..\..\..\GR551x_SDK_V1.7.0\external\freertos\include;..\..\..\..\GR551x_SDK_V1.7.0\external\segger_rtt;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\cmsis\include;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\include;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm;..\Src\config;..\Src\maxeye\inc;..\Src\config\config_216
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\GR551x_SDK_V1.7.0\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/: interrupt_gr55xx.c system_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../../GR551x_SDK_V1.7.0/components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../../GR551x_SDK_V1.7.0/drivers/src/: gr55xx_hal.c gr55xx_hal_gpio.c gr55xx_hal_uart.c gr55xx_hal_pwr.c gr55xx_hal_aon_wdt.c gr55xx_hal_exflash.c
  group gr_libraries
    ../../../../GR551x_SDK_V1.7.0/components/libraries/utility/: utility.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_timer/: app_timer.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/dfu_port/: dfu_port.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_log/: app_log.c
  group gr_profiles
    ../../../../GR551x_SDK_V1.7.0/components/profiles/otas/: otas.c
    ../../../../GR551x_SDK_V1.7.0/components/profiles/common/: ble_prf_utils.c
  group user_callback
    ../Src/user_callback/: user_gap_callback.c user_gatt_common_callback.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c user_dfu.c user_boot.c sign_verify.c
    ../Src/config/: user_config.h
    ./../Src/config/: custom_config.h
    ../../../../GR551x_SDK_V1.7.0/components/boards/: GR5515_SK.h
  group maxeye
    ../Src/maxeye/src/: maxeye_ble_cli.c maxeye_nvds.c maxeye_services.c
