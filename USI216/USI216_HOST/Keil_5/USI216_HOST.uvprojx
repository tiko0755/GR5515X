# Keil uVision project USI216_HOST.uvprojx, settings and files
target GR5515_SK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: USI216_HOST +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK
  c include: ..\Src\platform;..\Src\user;..\Src\config;..\..\..\GR551x_SDK_V1.7.0\components\app_drivers\inc;..\..\..\GR551x_SDK_V1.7.0\components\boards;..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\gr551x;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_assert;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_error;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_log;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_queue;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_timer;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_scheduler;..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_memory;..\..\..\GR551x_SDK_V1.7.0\components\libraries\hal_flash;..\..\..\GR551x_SDK_V1.7.0\components\libraries\pmu_calibration;..\..\..\GR551x_SDK_V1.7.0\components\libraries\ring_buffer;..\..\..\GR551x_SDK_V1.7.0\components\libraries\fault_trace;..\..\..\GR551x_SDK_V1.7.0\components\libraries\utility;..\..\..\GR551x_SDK_V1.7.0\components\patch\ind;..\..\..\GR551x_SDK_V1.7.0\components\profiles\bps;..\..\..\GR551x_SDK_V1.7.0\components\profiles\common;..\..\..\GR551x_SDK_V1.7.0\components\profiles\sample;..\..\..\GR551x_SDK_V1.7.0\components\sdk\;..\..\..\GR551x_SDK_V1.7.0\drivers\inc;..\..\..\GR551x_SDK_V1.7.0\external\freertos\include;..\..\..\GR551x_SDK_V1.7.0\external\segger_rtt;..\..\..\GR551x_SDK_V1.7.0\toolchain\cmsis\include;..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\include;..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm;..\Src\core;..\Src\user\board;..\Src\user\misc;..\Src\user\app;..\Src\user\CPS4041;..\Src\user\xUartDev;..\Src\user\xRingBuffer;..\Src\user\xCRC16;..\Src\user\cmd_consumer;..\Src\user\serviceClient;..\Src\user\test226;..\Src\user\test226\cap_ctrl;..\Src\user\test226\fetch_mac_proc;..\Src\user\test226\build_services_proc;..\Src\user\attached_sense;..\..\..\user;..\..\..\user\listener
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\GR551x_SDK_V1.7.0\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/: interrupt_gr55xx.c system_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../GR551x_SDK_V1.7.0/components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../GR551x_SDK_V1.7.0/drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_xqspi.c gr55xx_hal_pwr.c gr55xx_hal_gpio.c gr55xx_hal_aon_gpio.c gr55xx_hal_uart.c gr55xx_hal_i2c.c
  group gr_app_drivers
    ../../../GR551x_SDK_V1.7.0/components/app_drivers/src/: app_pwr_mgmt.c app_systick.c
  group gr_libraries
    ../../../GR551x_SDK_V1.7.0/components/libraries/utility/: utility.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_timer/: app_timer.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/ring_buffer/: ring_buffer.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_log/: app_log.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_error/: app_error.c cortex_backtrace.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_assert/: app_assert.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/fault_trace/: fault_trace.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_scheduler/: app_scheduler.c
    ../../../GR551x_SDK_V1.7.0/components/libraries/app_memory/: app_memory.c
  group gr_profiles
    ../../../GR551x_SDK_V1.7.0/components/profiles/common/: ble_prf_utils.c
  group external
    ../../../GR551x_SDK_V1.7.0/external/segger_rtt/: SEGGER_RTT.c
  group user_callback
    ../Src/user_callback/: user_gap_callback.c user_gatt_common_callback.c user_gattc_callback.c user_l2cap_callback.c user_sm_callback.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group core
    ./../Src/config/: custom_config.h
    ../Src/core/: gr55xx_hal_msp.c gr55xx_it.c main.c
  group usr/board
    ../Src/user/board/: thsBoard.c prvSrvUUID.C
  group usr/misc
    ../Src/user/misc/: misc.c
  group usr/cps4041
    ../Src/user/CPS4041/: CPS4041.c
  group usr/app
    ../Src/user/app/: user_app.c
  group usr/uartDev
    ../Src/user/xUartDev/: gr_uartDev.c
  group usr/crc16
    ../Src/user/xCRC16/: crc16.c
  group usr/xRingBuffer
    ../Src/user/xRingBuffer/: x_ring_buffer.c
  group usr/consumer
    ../Src/user/cmd_consumer/: cmd_consumer.c
  group usr/clientPrf
    ../Src/user/serviceClient/: clientSrvCB_0.c clientSrvCB_1.c clientSrvCB_2.c clientSrvCB_3.c clientSrvCB_4.c serviceClient.c
  group usr/test226
    ../Src/user/test226/: test226_batt.c test226_info.c test226_cmd.c test226_rssi.c unknown_svr1.c unknown_svr2.c unknown_svr3.c profile_usi216.c
  group usr/proc/fetch_mac
    ../Src/user/test226/build_services_proc/: build_services_proc.c
  group usr/attached_sense
    ../Src/user/attached_sense/: attached_sense.c
  group usr/charge_ctrl
    ../Src/user/test226/cap_ctrl/: cap_ctrl.c
  group listerner
    ../../../user/listener/: listener.c
