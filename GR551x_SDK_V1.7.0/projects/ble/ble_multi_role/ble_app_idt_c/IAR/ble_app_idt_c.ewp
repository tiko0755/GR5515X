# IAR project ble_app_idt_c.ewp, settings and files
configuration GR551x_SK (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GR5515_SK
  ICCARM.CCDiagSuppress: Ta023,Ta022
  ICCARM.CCIncludePath2: ..\Src\platform; ..\Src\user; ..\Src\config; ..\..\..\..\..\components\app_drivers\inc; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\drivers_ext\gr551x; ..\..\..\..\..\components\drivers_ext\st7735; ..\..\..\..\..\components\drivers_ext\vs1005; ..\..\..\..\..\components\libraries\app_alarm; ..\..\..\..\..\components\libraries\app_assert; ..\..\..\..\..\components\libraries\app_error; ..\..\..\..\..\components\libraries\app_key; ..\..\..\..\..\components\libraries\app_log; ..\..\..\..\..\components\libraries\app_queue; ..\..\..\..\..\components\libraries\app_timer; ..\..\..\..\..\components\libraries\at_cmd; ..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\components\libraries\dfu_master; ..\..\..\..\..\components\libraries\dfu_port; ..\..\..\..\..\components\libraries\gui; ..\..\..\..\..\components\libraries\gui\gui_config; ..\..\..\..\..\components\libraries\hal_flash; ..\..\..\..\..\components\libraries\hci_uart; ..\..\..\..\..\components\libraries\pmu_calibration; ..\..\..\..\..\components\libraries\ring_buffer; ..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\components\libraries\utility; ..\..\..\..\..\components\patch\ind; ..\..\..\..\..\components\profiles\ams_c; ..\..\..\..\..\components\profiles\ancs_c; ..\..\..\..\..\components\profiles\ans; ..\..\..\..\..\components\profiles\ans_c; ..\..\..\..\..\components\profiles\bas; ..\..\..\..\..\components\profiles\bas_c; ..\..\..\..\..\components\profiles\bcs; ..\..\..\..\..\components\profiles\bps; ..\..\..\..\..\components\profiles\common; ..\..\..\..\..\components\profiles\cscs; ..\..\..\..\..\components\profiles\cts; ..\..\..\..\..\components\profiles\cts_c; ..\..\..\..\..\components\profiles\dis; ..\..\..\..\..\components\profiles\dis_c; ..\..\..\..\..\components\profiles\gls; ..\..\..\..\..\components\profiles\gus; ..\..\..\..\..\components\profiles\gus_c; ..\..\..\..\..\components\profiles\hids; ..\..\..\..\..\components\profiles\hrrcps; ..\..\..\..\..\components\profiles\hrs; ..\..\..\..\..\components\profiles\hrs_c; ..\..\..\..\..\components\profiles\hts; ..\..\..\..\..\components\profiles\ias; ..\..\..\..\..\components\profiles\lls; ..\..\..\..\..\components\profiles\ndcs; ..\..\..\..\..\components\profiles\otas; ..\..\..\..\..\components\profiles\otas_c; ..\..\..\..\..\components\profiles\pass; ..\..\..\..\..\components\profiles\pass_c; ..\..\..\..\..\components\profiles\pcs; ..\..\..\..\..\components\profiles\rscs; ..\..\..\..\..\components\profiles\rscs_c; ..\..\..\..\..\components\profiles\rtus; ..\..\..\..\..\components\profiles\sample; ..\..\..\..\..\components\profiles\ths; ..\..\..\..\..\components\profiles\ths_c; ..\..\..\..\..\components\profiles\thscps; ..\..\..\..\..\components\profiles\tps; ..\..\..\..\..\components\profiles\wechat; ..\..\..\..\..\components\sdk\; ..\..\..\..\..\drivers\inc; ..\..\..\..\..\external\freertos\include; ..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\toolchain\cmsis\include; ..\..\..\..\..\toolchain\gr551x\include; ..\..\..\..\..\toolchain\gr551x\source\arm; ..\..\..\..\..\components\profiles\idts_c
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: load_app.bin
  postbuild: ..\..\..\..\..\build\scripts\after_build_for_IAR.bat
  ILINK.IlinkOutputFile: iar_app.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\toolchain\gr551x\source\iar\gr5515.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\components\patch\symbol_table\rom_symbol_iar.txt
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\components\sdk\linker\lib_iar\ble_sdk.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group external
    ../../../../../external/segger_rtt/: SEGGER_RTT.c
  group gr_app_drivers
    ../../../../../components/app_drivers/src/: app_dma.c app_dual_tim.c app_gpiote.c app_io.c app_pwr_mgmt.c app_systick.c app_uart.c
  group gr_arch
    ../../../../../toolchain/gr551x/source/: interrupt_gr55xx.c platform_gr55xx.c system_gr55xx.c
  group gr_drivers
    ../../../../../drivers/src/: gr55xx_hal.c gr55xx_hal_aon_gpio.c gr55xx_hal_dual_tim.c gr55xx_hal_exflash.c gr55xx_hal_gpio.c gr55xx_hal_pwr.c gr55xx_hal_rng.c gr55xx_hal_uart.c gr55xx_hal_xqspi.c
  group gr_libraries
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_error/: app_error.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/bsp/: bsp.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/sensorsim/: sensorsim.c
    ../../../../../components/libraries/utility/: utility.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
    ../Src/user/: idts_c.c
  group gr_startup
    ../../../../../toolchain/gr551x/source/iar/: startup_gr55xx.s
  group user_app
    ../Src/user/: app_idt.c main.c user_app.c
    ../Src/config/: custom_config.h
    ../../../../../components/boards/: GR5515_SK.h
  group user_callback
    ../Src/user_callback/: user_gap_callback.c user_gatt_common_callback.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
