<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ble_app_idt_c.ewp</path>
    </project>
    <batchBuild />
</workspace>
