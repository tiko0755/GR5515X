# Keil uVision project ble_app_hrs_gh3011.uvprojx, settings and files
target GR5515_SK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ble_app_hrs_gh3011 +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK
  c include: ..\Src\gh3011;..\Src\platform;..\Src\user;..\Src\config;..\..\..\..\..\components\app_drivers\inc;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr551x;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\lns;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\drivers\inc;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\toolchain\cmsis\include;..\..\..\..\..\toolchain\gr551x\include;..\..\..\..\..\toolchain\gr551x\source\arm
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\..\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\..\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../../../../toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../../../toolchain/gr551x/source/: interrupt_gr55xx.c system_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../../../components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../../../drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_xqspi.c gr55xx_hal_aon_gpio.c gr55xx_hal_gpio.c gr55xx_hal_pwr.c gr55xx_hal_spi.c gr55xx_hal_uart.c gr55xx_hal_i2c.c gr55xx_hal_tim.c
  group gr_app_drivers
    ../../../../../components/app_drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_systick.c app_spi.c app_i2c.c app_tim.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/sensorsim/: sensorsim.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_error/: app_error.c cortex_backtrace.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/dfu_port/: dfu_port.c
    ../../../../../components/libraries/hci_uart/: hci_uart.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/bsp/: bsp.c
    ../../../../../components/libraries/fault_trace/: fault_trace.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
    ../../../../../components/profiles/bas/: bas.c
    ../../../../../components/profiles/dis/: dis.c
    ../../../../../components/profiles/hrs/: hrs.c
    ../../../../../components/profiles/otas/: otas.c
    ../../../../../components/profiles/lns/: lns.c
  group gr_drivers_ext
    ../../../../../components/drivers_ext/st7735/: st7735.c st7735_config.c
  group gr_gui
    ../../../../../components/libraries/gui/: gui_animation.c gui_basic.c gui_color.c gui_convert_color.c gui_font_gb2312.c gui_font5_7.c gui_font8_8.c gui_font_other.c
    ../../../../../components/libraries/gui/gui_config/: gui_animation_config.c gui_lcd_config.c gui_gb2312_config.c
  group external
    ../../../../../external/segger_rtt/: SEGGER_RTT.c
  group gh3011
    ../Src/gh3011/: gh3011_example_comm_pkg.c gh3011_example_ctrl.c gh3011_example_port.c gh3011_example_process.c gh3011_example_reg_array.c lib_app_cmd_send_keil_cortexM4l.lib hbd_ctrl_KEIL5_M4-fp.lib hbd_communicate_KEIL5_M4-fp.lib
  group user_callback
    ../Src/user_callback/: user_gap_callback.c user_sm_callback.c user_gatt_common_callback.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c user_gui.c
    ./../Src/config/: custom_config.h
    ../../../../../components/boards/: GR5515_SK.h
