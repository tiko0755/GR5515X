# Keil uVision project app_rtc.uvprojx, settings and files
target GR5515_SK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app_rtc +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK,DRIVER_TEST
  c include: ..\Inc;..\Src\config;..\..\..\..\..\components\app_drivers\inc;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr551x;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\sdk\;..\..\..\..\..\drivers\inc;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\toolchain\cmsis\include;..\..\..\..\..\toolchain\gr551x\include;..\..\..\..\..\toolchain\gr551x\source\arm;..\..\..\..\..\components\libraries\ble\ble_time
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x30000000 size 0x40000
  scatter file: ..\..\..\..\..\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\..\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../../../../toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../../../toolchain/gr551x/source/: system_gr55xx.c interrupt_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../../../components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../../../drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_adc.c gr55xx_hal_gpio.c gr55xx_hal_aon_gpio.c gr55xx_hal_uart.c gr55xx_hal_calendar.c gr55xx_hal_pwr.c
  group gr_drivers_app
    ../../../../../components/app_drivers/src/: app_gpiote.c app_io.c app_pwr_mgmt.c app_systick.c app_uart.c app_dma.c app_rtc.c
  group gr_libraries
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/drivers_ext/gr551x/: gr551x_adc_voltage_api.c
    ../../../../../components/libraries/bsp/: bsp.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/ble/ble_time/: ble_time.c
    ../../../../../components/libraries/app_assert/: app_assert.c
  group user_app
    ../Src/: main.c
    ../Src/config/: custom_config.h
    ../../../../../components/boards/: GR5515_SK.h
